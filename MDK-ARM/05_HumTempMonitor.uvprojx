# Keil uVision project 05_HumTempMonitor.uvprojx, settings and files
target 05_HumTempMonitor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: 05_HumTempMonitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../APP;../HARDWARE/OLED;../HARDWARE/AHT21;../HARDWARE/SoftI2C;../HARDWARE/ADXL345;../HARDWARE/DS18B20;../HARDWARE/DS1302;../HARDWARE/Battery
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group BSP/OLED
    ../HARDWARE/OLED/: oled.c oled_gfx.c
  group BSP/AHT21
    ../HARDWARE/AHT21/: aht21.c
  group BSP/SoftI2C
    ../HARDWARE/SoftI2C/: soft_i2c.c
  group BSP/ADXL345
    ../HARDWARE/ADXL345/: adxl345.c
  group BSP/DS18B20
    ../HARDWARE/DS18B20/: ds18b20.c
  group BSP/DS1302
    ../HARDWARE/DS1302/: ds1302.c
  group BSP/Battery
    ../HARDWARE/Battery/: battery.c
  group Application/User/App
    ../APP/: app_power.c app_sensor.c app_time.c app_ui.c app_imu.c
software components: CMSIS:CORE 4.3.0
